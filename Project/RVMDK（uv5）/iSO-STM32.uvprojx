# Keil uVision project iSO-STM32.uvprojx, settings and files
target RFID (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\gpio;..\..\Hardware\Common;..\..\Hardware\ESP8266;..\..\Hardware\SysTick;..\..\Hardware\Test;..\..\Hardware\usart;..\..\Hardware\RC522;..\..\Hardware\delay;..\..\Hardware\sys;..\..\Hardware\LED;..\..\Hardware\MQTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group HARDWARE
    ../../Hardware/Common/: Common.c
    ../../Hardware/ESP8266/: bsp_esp8266.c
    ../../Hardware/SysTick/: bsp_SysTick.c
    ../../Hardware/Test/: test.c
    ../../Hardware/usart/: bsp_usart1.c
    ../../Hardware/RC522/: rc522.c
    ../../Hardware/delay/: delay.c
    ../../Hardware/sys/: sys.c
    ../../Hardware/LED/: led.c
    ../../Hardware/MQTT/: mqtt.c
